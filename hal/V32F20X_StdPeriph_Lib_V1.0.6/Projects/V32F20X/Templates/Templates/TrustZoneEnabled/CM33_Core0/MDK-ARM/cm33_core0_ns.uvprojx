# Keil uVision project cm33_core0_ns.uvprojx, settings and files
target template (6180000::V6.18::ARMCLANG)
  device: V32F209IWTx:CM33-0 Vangotech
  pack: Vango.V32F20x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: cm33_core0_ns
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: V32F209XX,V32F20XXX_CM33_CORE0,_USE_TARGET_DRIVER
  c include: .\;..\NonSecure\Inc;..\..\..\..\..\..\..\Libraries\CMSIS\cm33\core0;..\..\..\..\..\..\..\Libraries\Drivers\Inc;..\..\..\..\..\..\..\Libraries\include;..\..\..\..\..\..\..\BSP;..\TrustZone
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x80000
  memory RVCT9: RAM 0x20040000 size 0x40000
  link misc: .\..\Trustzone\secure_nsclib.o
  group MDK-ARM
    ../../../../../../../Libraries/CMSIS/cm33/core0/: system_target_cm33_core0_ns.c
    ./: startup_target_cm33_core0_ns.S
  group BSP
    ../../../../../../../BSP/: board.c
  group User
    ../NonSecure/Src/: main.c target_isr.c
    ../NonSecure/Inc/: lib_conf.h
  group FWLib
    ../../../../../../../Libraries/Drivers/Src/: lib_adc.c lib_bpwm.c lib_btimer.c lib_can.c lib_clk.c lib_comp.c misc.c lib_crc.c lib_dac.c lib_dcmi.c lib_eadc.c lib_enceng.c lib_enceng_crypt.c lib_enceng_hash.c lib_flash.c lib_gpio.c lib_gpio_ex.c lib_i2c.c lib_i2s.c lib_iso7816.c lib_mailbox.c lib_pmu.c lib_rng.c lib_rtc.c lib_rtc_comp.c lib_rtc_ex.c lib_sdio.c lib_std.c lib_timer.c lib_u32k.c lib_uart.c lib_wdt.c lib_bdma.c lib_bspi.c lib_crypt.c lib_dma.c lib_hfm.c lib_ospi.c lib_spi.c lib_syscfg0.c lib_syscfg1.c lib_syscfglp.c lib_ramfunc.c
  group Doc
    ../: readme_ns.txt
software components: CMSIS:CORE 5.6.0
