# Keil uVision project cm0.uvprojx, settings and files
target template (6180000::V6.18::ARMCLANG)
  device: V32F209IWTx:CM0 Vangotech
  pack: Vango.V32F20x_DFP.1.0.1
  cpu: IRAM(0x21000000,0x00040000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: V32F209XX,V32F20XXX_CM0_CORE,_USE_TARGET_DRIVER
  c include: .\;..\Inc;..\..\..\..\..\..\..\Libraries\CMSIS\cm0;..\..\..\..\..\..\..\Libraries\Drivers\Inc;..\..\..\..\..\..\..\Libraries\include;..\..\..\..\..\..\..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x21000000 size 0x40000
  group MDK-ARM
    ./: startup_target_cm0.S
    ../../../../../../../Libraries/CMSIS/cm0/: system_target_cm0.c
  group BSP
    ../../../../../../../BSP/: board.c
  group User
    ../Src/: main.c target_isr.c
    ../Inc/: lib_conf.h
  group FWLib
    ../../../../../../../Libraries/Drivers/Src/: lib_bpwm.c lib_btimer.c lib_clk.c misc.c lib_crypt.c lib_flash.c lib_gpio.c lib_gpio_ex.c lib_hfm.c lib_i2c.c lib_iso7816.c lib_mailbox.c lib_pmu.c lib_rtc.c lib_rtc_comp.c lib_rtc_ex.c lib_std.c lib_u32k.c lib_uart.c lib_wdt.c lib_bdma.c lib_bspi.c lib_syscfg1.c lib_syscfglp.c lib_ramfunc.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
