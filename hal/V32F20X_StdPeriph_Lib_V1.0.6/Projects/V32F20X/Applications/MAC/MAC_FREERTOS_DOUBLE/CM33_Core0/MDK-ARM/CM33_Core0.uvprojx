# Keil uVision project CM33_Core0.uvprojx, settings and files
target template (6180000::V6.18::ARMCLANG)
  device: V32F209IWTx:CM33-0 Vangotech
  pack: Vango.V32F20x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: V32F209XX,V32F20XXX_CM33_CORE0,_DUAL_MODE,_PM_MODE,_USE_TARGET_DRIVER,OS_CRITICAL_METHOD
  c include: ..\MDK-ARM;..\Inc;..\..\..\..\..\..\..\Libraries\CMSIS\cm33\core0;..\..\..\..\..\..\..\Libraries\Drivers\Inc;..\..\..\..\..\..\..\Libraries\include;..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\include;..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS_V2;..\..\..\..\..\..\..\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\arch;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src\api;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src\core;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src\core\ipv4;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src\core\snmp;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src\include;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src\include\ipv4;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1\src\include\netif;..\..\..\..\..\..\..\Middlewares\Third_Party\lwip-1.4.1;..\..\..\..\..\..\..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group MDK-ARM
    ./: startup_target_cm33_core0.S
    ../../../../../../../Libraries/CMSIS/cm33/core0/: system_target_cm33_core0.c
  group User
    ../Src/: lan8720.c lwip_comm.c main.c target_isr.c tcp_server_test.c timer.c udp_test.c delay.c lib_eth.c
  group BSP
    ../../../../../../../BSP/: board.c
  group FWLib
    ../../../../../../../Libraries/Drivers/Src/: lib_clk.c misc.c lib_gpio.c lib_std.c lib_syscfg0.c lib_uart.c lib_ramfunc.c lib_flash.c
  group Middlewares/FreeRTOS
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
  group Middlewares/FreeRTOS/portable
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM33_NTZ/non_secure/: port.c portasm.c
    ../../../../../../../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Middlewares/lwip
    ../../../../../../../Middlewares/Third_Party/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../../Middlewares/Third_Party/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../../Middlewares/Third_Party/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c udp.c lwip_timers.c
    ../../../../../../../Middlewares/Third_Party/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
    ../Src/: sys_arch.c
software components: CMSIS:CORE 5.6.0
