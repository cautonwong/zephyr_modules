# Keil uVision project cm33_core0.uvprojx, settings and files
target template (6180000::V6.18::ARMCLANG)
  device: V32F209IWTx:CM33-0 Vangotech
  pack: Vango.V32F20x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: V32F209XX,V32F20XXX_CM33_CORE0,_USE_TARGET_DRIVER
  c include: .\;..\..\..\..\..\..\..\BSP;..\..\..\..\..\..\..\Libraries\Drivers\Inc;..\..\..\..\..\..\..\Libraries\include;..\Inc;..\..\..\..\..\..\..\Libraries\CMSIS\cm33\core0
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group MDK-ARM
    ./: startup_target_cm33_core0.S
    ../../../../../../../Libraries/CMSIS/cm33/core0/: system_target_cm33_core0.c
  group User
    ../Src/: main.c target_isr.c hyperbus_psram.c
  group FWLib
    ../../../../../../../Libraries/Drivers/Src/: lib_clk.c lib_comp.c misc.c lib_dcmi.c lib_bdma.c lib_dma.c lib_enceng.c lib_enceng_hash.c lib_gpio.c lib_i2c.c lib_i2s.c lib_mailbox.c lib_rng.c lib_bspi.c lib_spi.c lib_ospi.c lib_std.c lib_syscfg1.c lib_syscfg0.c lib_syscfglp.c lib_uart.c lib_wdt.c lib_ramfunc.c lib_flash.c
  group BSP
    ../../../../../../../BSP/: board.c
software components: CMSIS:CORE 5.6.0
