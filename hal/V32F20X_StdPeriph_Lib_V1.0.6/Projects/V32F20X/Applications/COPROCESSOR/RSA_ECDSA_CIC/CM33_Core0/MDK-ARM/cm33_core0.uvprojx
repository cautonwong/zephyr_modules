# Keil uVision project cm33_core0.uvprojx, settings and files
target template (6180000::V6.18::ARMCLANG)
  device: V32F209IWTx:CM33-0 Vangotech
  pack: Vango.V32F20x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: V32F209XX,V32F20XXX_CM33_CORE0,_PM_MODE,_USE_TARGET_DRIVER,__MARS_PLUS__,MBEDTLS_CONFIG_FILE
  c include: ..\MDK-ARM;..\Inc;..\..\..\..\..\..\..\Libraries\CMSIS\cm33\core0;..\..\..\..\..\..\..\Libraries\Drivers\Inc;..\..\..\..\..\..\..\Libraries\include;..\..\..\..\..\..\..\BSP;..\..\..\..\..\..\..\Middlewares\My_Party\mbedtls_CPP;..\..\..\..\..\..\..\Middlewares\My_Party\mbedtls_CPP\library;..\..\..\..\..\..\..\Middlewares\My_Party\mbedtls_CPP\include;..\..\..\..\..\..\..\Middlewares\My_Party\mbedtls_CPP\port\ksdk;..\..\..\..\..\..\..\Middlewares\My_Party\mbedtls_CPP\port;..\..\..\..\..\..\..\Middlewares\My_Party\mbedtls_CPP\include\mbedtls
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20010000 size 0xe0000
  memory RVCT10: RAM 0x200f0000 size 0x10000
  group MDK-ARM
    ./: startup_target_cm33_core0.S
    ../../../../../../../Libraries/CMSIS/cm33/core0/: system_target_cm33_core0.c
  group BSP
    ../../../../../../../BSP/: board.c
  group User
    ../Src/: main.c target_isr.c ccp_ver.c ecc.c lib_ccp.c
    ./: CIC_data.h test_ecmul256.h
  group FWLib
    ../../../../../../../Libraries/Drivers/Src/: lib_clk.c misc.c lib_gpio.c lib_syscfg0.c lib_dma.c lib_std.c lib_uart.c lib_ramfunc.c lib_flash.c
  group mbedtls/library
    ../../../../../../../Middlewares/My_Party/mbedtls_CPP/library/: aes.c aesni.c arc4.c aria.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c ccm.c certs.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hkdf.c hmac_drbg.c md.c md_wrap.c md2.c md4.c md5.c memory_buffer_alloc.c net_sockets.c nist_kw.c oid.c padlock.c pem.c pk.c pk_wrap.c pkcs5.c pkcs11.c pkcs12.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write_crt.c x509write_csr.c xtea.c
  group mbedtls/port/ksdk
    ../../../../../../../Middlewares/My_Party/mbedtls_CPP/port/ksdk/: aes_alt.c des_alt.c ecp_alt.c ecp_alt_ksdk.c ecp_curves_alt.c ksdk_mbedtls.c
software components: CMSIS:CORE 5.6.0
