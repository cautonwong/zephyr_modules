# Keil uVision project cm33_core0.uvprojx, settings and files
target template (6160000::V6.16::ARMCLANG)
  device: V32F209IWTx:CM33-0 Vangotech
  pack: Vango.V32F20x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template
  AfterMake: $tool\..\..\ARM\ARMCC\bin\fromelf.exe  --bin --output ./template.bin  Objects/template.axf
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: V32F209XX,V32F20XXX_CM33_CORE0,_USE_TARGET_DRIVER
  c include: .\;..\Inc;..\..\..\..\..\..\..\Libraries\CMSIS\cm33\core0;..\..\..\..\..\..\..\Libraries\Drivers\Inc;..\..\..\..\..\..\..\Libraries\include;..\..\..\..\..\..\..\BSP;..\..\..\..\..\..\..\Middlewares\My_Party\USB_Host_Library\Core\Inc;..\..\..\..\..\..\..\Middlewares\My_Party\USB_Host_Library\Class\MSC\Inc;..\..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src
  library: MicroLIB
  memory RVCT4: ROM 0x10000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group MDK-ARM
    ./: startup_target_cm33_core0.S
    ../../../../../../../Libraries/CMSIS/cm33/core0/: system_target_cm33_core0.c
  group BSP
    ../../../../../../../BSP/: board.c
  group User
    ../Src/: main.c target_isr.c
    ../Inc/: lib_conf.h
  group FWLib
    ../../../../../../../Libraries/Drivers/Src/: misc.c lib_syscfg0.c lib_syscfg1.c lib_syscfglp.c lib_std.c lib_clk.c lib_gpio.c lib_uart.c lib_ramfunc.c lib_flash.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
