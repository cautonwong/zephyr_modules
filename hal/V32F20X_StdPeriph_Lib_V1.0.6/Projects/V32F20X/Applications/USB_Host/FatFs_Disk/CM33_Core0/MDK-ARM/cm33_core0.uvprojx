# Keil uVision project cm33_core0.uvprojx, settings and files
target template (6180000::V6.18::ARMCLANG)
  device: V32F209IWTx:CM33-0 Vangotech
  pack: Vango.V32F20x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00080000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: V32F209XX,V32F20XXX_CM33_CORE0,_USE_TARGET_DRIVER,USE_USB_OTG_HS
  c include: .\;..\Inc;..\..\..\..\..\..\..\Libraries\CMSIS\cm33\core0;..\..\..\..\..\..\..\Libraries\Drivers\Inc;..\..\..\..\..\..\..\Libraries\include;..\..\..\..\..\..\..\BSP;..\..\..\..\..\..\..\Middlewares\Third_Party\FatFs\src;..\..\..\..\..\..\..\Middlewares\My_Party\USB_HOST_Library\Class\MSC\inc;..\..\..\..\..\..\..\Middlewares\My_Party\USB_HOST_Library/Core/inc;..\..\..\..\..\..\..\Middlewares\My_Party\USB_OTG_Driver/inc;..\USB_User
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group MDK-ARM
    ./: startup_target_cm33_core0.S
    ../../../../../../../Libraries/CMSIS/cm33/core0/: system_target_cm33_core0.c
  group BSP
    ../../../../../../../BSP/: board.c
  group User
    ../Src/: main.c target_isr.c
    ../Inc/: lib_conf.h
  group FWLib
    ../../../../../../../Libraries/Drivers/Src/: lib_std.c misc.c lib_syscfg0.c lib_syscfg1.c lib_syscfglp.c lib_gpio.c lib_clk.c lib_mailbox.c lib_wdt.c lib_dma.c lib_bdma.c lib_rtc.c lib_uart.c lib_timer.c lib_flash.c lib_ramfunc.c
  group FAT_FS
    ../../../../../../../Middlewares/Third_Party/FatFs/src/: ff.c
  group USB_Host/Core
    ../../../../../../../Middlewares/My_Party/USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_Host/Driver
    ../../../../../../../Middlewares/My_Party/USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group App
    ../USB_User/: usb_bsp.c usbh_usr.c
  group USB_Host/Class/MSC
    ../../../../../../../Middlewares/My_Party/USB_HOST_Library/Class/MSC/src/: usbh_msc_bot.c usbh_msc_core.c usbh_msc_fatfs.c usbh_msc_scsi.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.6.0
