# Keil uVision project template.uvprojx, settings and files
target template (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: V85XXP Generic
  pack: Vango.V85XXP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M0") CLOCK(6553600) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_TARGET_DRIVER
  c include: ..\Inc;..\Src;..\..\..\..\Libraries\Lib_Driver\inc;..\..\..\..\Libraries\Lib_Driver\src;..\..\..\..\Libraries\CMSIS\device;..\..\..\..\Libraries\CMSIS\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000100 size 0x1f00
  group Template/User
    ../Src/: main.c target_isr.c v_stdio.c ymodem.c upload.c download.c common.c
    ../Inc/: lib_conf.h
  group Template/MDK-ARM
    ./: startup_target.s
    ../../../../Libraries/CMSIS/device/: system_target.c
  group FWLib
    ../../../../Libraries/Lib_Driver/src/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_iso7816.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c lib_cmp.c
  group FWLib/Device
    ../../../../Libraries/CMSIS/device/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
software components: CMSIS:CORE 5.2.0
