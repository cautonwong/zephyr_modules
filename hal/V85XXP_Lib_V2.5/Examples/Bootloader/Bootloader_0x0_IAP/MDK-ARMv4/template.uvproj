# Keil uVision project template.uvproj, settings and files
target template (ARM-ADS)
  device: V85XXP Vango
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x0-0x7FFFF) CLOCK(6553600) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: template
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_TARGET_DRIVER
  c include: ..\Inc;..\Src;..\..\..\..\Libraries\Lib_Driver\inc;..\..\..\..\Libraries\Lib_Driver\src;..\..\..\..\Libraries\CMSIS\device;..\..\..\..\Libraries\CMSIS\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x4000
  memory RVCT9: RAM 0x20000100 size 0x1f00
  group Template/User
    ../Src/: main.c target_isr.c v_stdio.c common.c download.c upload.c ymodem.c
    ../Inc/: lib_conf.h
  group Template/MDK_ARM
    ./: startup_target.s
    ../../../../Libraries/CMSIS/device/: system_target.c
  group FWLib
    ../../../../Libraries/Lib_Driver/src/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_iso7816.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c lib_cmp.c
  group FWLib/Device
    ../../../../Libraries/CMSIS/device/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
