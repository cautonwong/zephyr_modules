# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: V85XXP VANGO V85XXP
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_TARGET_DRIVER
  ICCARM.CCIncludePath2: ..\Src; ..\Inc; ..\..\..\..\Libraries\Lib_Driver\inc; ..\..\..\..\Libraries\Lib_Driver\src; ..\..\..\..\Libraries\CMSIS\device; ..\..\..\..\Libraries\CMSIS\include; ..\..\..\..\Libraries\CMSIS\CMSIS_include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.hex
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkIcfFile: target_flash.icf
  ILINK.IlinkProgramEntryLabel: main
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_V85XX_DRIVER; __V85XX_EWARM_USED
  ICCARM.CCIncludePath2: ..\Src; ..\Inc; ..\..\..\..\Libraries\V85XX_Driver\inc; ..\..\..\..\Libraries\V85XX_Driver\src; ..\..\..\..\Libraries\CMSIS\device; ..\..\..\..\Libraries\CMSIS\include
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkIcfFile: v85xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group EWARM
    ./: startup_target.s
    ../../../../Libraries/CMSIS/device/: system_target.c
  group FWLib
    ../../../../Libraries/Lib_Driver/src/: lib_adc.c lib_adc_tiny.c lib_ana.c lib_clk.c lib_cmp.c lib_crypt.c lib_dma.c lib_flash.c lib_gpio.c lib_i2c.c lib_iso7816.c lib_lcd.c lib_misc.c lib_pmu.c lib_pwm.c lib_rtc.c lib_spi.c lib_tmr.c lib_u32k.c lib_uart.c lib_version.c lib_wdt.c
  group FWLib/Device
    ../../../../Libraries/CMSIS/device/: lib_CodeRAM.c lib_cortex.c lib_LoadNVR.c
  group User
    ../Inc/: lib_conf.h
    ../Src/: main.c target_isr.c v_stdio.c
